# Keil uVision project UART4.uvproj, settings and files
target UART4 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: UART4 +hex
  group Source
    ./: UART4.c isr.asm 功能说明.txt
