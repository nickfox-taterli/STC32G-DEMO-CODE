# Keil uVision project UART3.uvproj, settings and files
target UART3 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: UART3 +hex
  group Source
    ./: UART3.c isr.asm 功能说明.txt
