# Keil uVision project STC32G-usart1_spi_usart2_spi-demo.uvproj, settings and files
target demo (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: STC32G-usart1_spi_usart2_spi-demo +hex
  link misc: REMOVEUNUSED
  group main
    ./src/: main.c
    ./: 功能说明.txt
