# Keil uVision project SPI-M-S.uvproj, settings and files
target SPI-PM25LV040 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: SPI-M-S +hex
  group Source
    ./: SPI-M-S.c isr.asm 功能说明.txt
