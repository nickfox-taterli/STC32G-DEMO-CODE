# Keil uVision project DS18B20.uvproj, settings and files
target DS18B20 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: DS18B20 +hex
  group Source
    ./: DS18B20.asm 功能说明.txt
