# Keil uVision project UART1-UART2.uvproj, settings and files
target UART1-UART2 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: UART1-UART2 +hex
  group Source
    ./: UART1-UART2.asm 功能说明.txt
