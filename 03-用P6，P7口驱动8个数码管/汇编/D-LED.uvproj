# Keil uVision project D-LED.uvproj, settings and files
target D-LED (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: D-LED +hex
  group Source
    ./: D-LED.asm 功能说明.txt
