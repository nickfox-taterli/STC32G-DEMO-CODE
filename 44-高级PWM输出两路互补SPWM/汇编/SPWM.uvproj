# Keil uVision project SPWM.uvproj, settings and files
target SPWM (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: SPWM +hex
  group Source
    ./: SPWM.asm 功能说明.txt
