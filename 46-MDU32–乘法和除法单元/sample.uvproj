# Keil uVision project sample.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: sample +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: sample.c STC32_MDU32_V1.1.LIB 功能说明.txt
