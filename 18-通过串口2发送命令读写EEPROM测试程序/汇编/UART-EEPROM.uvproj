# Keil uVision project UART-EEPROM.uvproj, settings and files
target UART-EEPROM (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: UART-EEPROM +hex
  group Source
    ./: UART-EEPROM.asm 功能说明.txt
