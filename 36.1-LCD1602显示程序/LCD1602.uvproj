# Keil uVision project LCD1602.uvproj, settings and files
target LCD128x64 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: LCD1602 +hex
  group Source
    ./: LCD1602.c 功能说明.txt
