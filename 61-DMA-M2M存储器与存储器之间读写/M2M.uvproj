# Keil uVision project M2M.uvproj, settings and files
target UART1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: M2M +hex
  group Source
    ./: isr.asm M2M.c 功能说明.txt
