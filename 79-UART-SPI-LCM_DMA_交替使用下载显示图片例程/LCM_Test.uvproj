# Keil uVision project LCM_Test.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: LCM_Test +hex
  group Source Group 1
    ./Sources/: main.c SPI_Flash.c ISR.asm uart.c lcm.c iap_eeprom.c
    ./: 功能说明.txt
