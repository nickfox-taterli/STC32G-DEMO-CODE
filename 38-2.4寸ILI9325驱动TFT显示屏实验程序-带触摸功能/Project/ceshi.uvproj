# Keil uVision project ceshi.uvproj, settings and files
target QD-TFT (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: ceshi +hex
  link misc: REMOVEUNUSED
  group USER
    ../GUI/: gui.c
    ../USER/: main.c test.c 功能说明.txt
  group SYSTEM
    ../sys/: sys.c
  group HARDWARE
    ../LCD/: LCD.c
    ../touch/: touch.c
