# Keil uVision project I2C.uvproj, settings and files
target I2C (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: I2C +hex
  group Source
    ./: I2C.c ISR.asm 功能说明.txt
