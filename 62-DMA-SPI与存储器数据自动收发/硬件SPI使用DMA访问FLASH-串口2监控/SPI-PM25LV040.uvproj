# Keil uVision project SPI-PM25LV040.uvproj, settings and files
target SPI-PM25LV040 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: SPI-PM25LV040 +hex
  group Source
    ./: SPI-PM25LV040.c ISR.asm 功能说明.txt
