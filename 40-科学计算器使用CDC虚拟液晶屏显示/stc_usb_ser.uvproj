# Keil uVision project stc_usb_ser.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: stc_usb_ser +hex
  group Source Group 1
    ./src/: main.c
    ./: blog.txt
    ../COMM/: stc_usb_cdc_32.LIB
  group hardware
    ./ware/: tim.c oled.c eeprom.c rtc.c key.c spi.c
  group middledrive
    ./middle/: middle.c
  group user
    ./: menu.c keyboard.c
    ./user/: nor_cal.c fun.c matrix.c funcpic.c solve.c sensus.c calculus.c set.c
