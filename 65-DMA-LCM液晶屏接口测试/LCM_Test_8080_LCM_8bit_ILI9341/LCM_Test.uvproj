# Keil uVision project LCM_Test.uvproj, settings and files
target LCM_Test (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: LCM_Test +hex
  group Source
    ./: LCM_Test.c ISR.asm 功能说明.txt
