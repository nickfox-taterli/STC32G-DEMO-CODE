# Keil uVision project wakeup_timer.uvproj, settings and files
target wakeup_timer (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: wakeup_timer +hex
  group Source
    ./: wakeup_timer.asm 功能说明.txt
