# Keil uVision project I2C_Slave_INT.uvproj, settings and files
target I2C_Slave_INT (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: I2C_Slave_INT +hex
  group Source
    ./: I2C_Slave_INT.asm 功能说明.txt
