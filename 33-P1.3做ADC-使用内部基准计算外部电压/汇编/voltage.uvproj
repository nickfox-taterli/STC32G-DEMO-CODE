# Keil uVision project voltage.uvproj, settings and files
target voltage (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: voltage +hex
  group Source
    ./: voltage.asm 功能说明.txt
